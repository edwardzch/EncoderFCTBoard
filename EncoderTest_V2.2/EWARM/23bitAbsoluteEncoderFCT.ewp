# IAR project 23bitAbsoluteEncoderFCT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV30F128xxx10 NXP MKV30F128xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MKV30F128VLF10; FRDM_KV31F; FREEDOM
  ICCARM.CCIncludePath2: ..\Project\inc; ..\Drivers\KV30_HAL_Driver\inc; ..\Drivers\CMSIS\Device; ..\BSP\inc; ..\UserConfig\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 23bitAbsoluteEncoderFCTV2.2.bin
  ILINK.IlinkOutputFile: Encoder_kv30_ada4571.out
  ILINK.IlinkIcfFile: C:\Users\zhangch64\Desktop\FCT\Program\EncoderTest_V2.1\EWARM\MKV30F128_APP.icf
  ILINK.IlinkAdditionalLibs: ..\BSP\src\MT6835_NLC.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: ReadMe.txt
  group Application/EWARM
    ./: startup_MKV30F12810.s
  group Application/User
    ../Project/src/: main.c
  group BSP
    ../BSP/src/: Function.c iap_function.c MGTMagneticEncoder.c ModBus.c MultiturnMagneticEncoder.c MultiturnOpticalEncoder.c NXPMagneticEncoder.c SensAREncoder.c TamagawaEncoder.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/: system_MKV30F12810.c
  group Drivers/KV30_HAL_Driver
    ../Drivers/KV30_HAL_Driver/src/: fsl_adc16.c fsl_clock.c fsl_dmamux.c fsl_dspi.c fsl_edma.c fsl_ftm.c fsl_gpio.c fsl_i2c.c fsl_pdb.c fsl_pit.c fsl_smc.c fsl_uart.c fsl_uart_edma.c
  group UserConfig
    ../UserConfig/src/: clock_config.c gpio_config.c pit_congfig.c uart_config.c
